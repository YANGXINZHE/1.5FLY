# Keil uVision project FLY.uvproj, settings and files
target FLY (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: FLY +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --c99
  c include: .\APP;.\BSP;.\LIB;.\SYSTEM\delay;.\SYSTEM\sys
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group SYS
    ./APP/: main.c stm32f10x_it.c sysconfig.h
  group APP
    ./APP/: Control.c Control.h Data_Transfer.c Data_Transfer.h Imu.c Imu.h Rc.c Rc.h
  group BSP
    ./BSP/: ADC.c ADC.h BSP.c BSP.h eeprom.c eeprom.h Led.c Led.h Moto.c Moto.h MPU6050.c MPU6050.h Nrf24l01.c Nrf24l01.h Spi.c Spi.h Tim_pwm_in.c Tim_pwm_in.h Tim3.c Tim3.h Usart1.c Usart1.h Usart2.c Usart2.h
  group LIB
    ./LIB/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c system_stm32f10x.c startup_stm32f10x_md.s stm32f10x_conf.h
  group IIC
    ./BSP/: i2cdev.c i2croutines.c i2cdev.h i2croutines.h
  group system
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
