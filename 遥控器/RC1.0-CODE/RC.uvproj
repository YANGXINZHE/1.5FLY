# Keil uVision project RC.uvproj, settings and files
target RC (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: RC +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\USER
  group MAIN
    ./USER/: RC.C AD.C delay.c NRF24L01.C uart.c eeprom.c
    ./: STARTUP.A51
